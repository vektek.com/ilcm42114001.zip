ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(0.,0.,0.));
#20=DIRECTION('',(-1.,0.,0.));
#21=DIRECTION('',(0.,0.,1.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=CYLINDRICAL_SURFACE('',#22,15.8623);
#24=CARTESIAN_POINT('',(-3.3029772846325,0.,0.));
#25=DIRECTION('',(-1.,0.,0.));
#26=DIRECTION('',(0.,0.,1.));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,15.8623);
#29=CARTESIAN_POINT('',(-3.3029772846325,0.,15.8623));
#30=VERTEX_POINT('',#29);
#31=EDGE_CURVE('E38',#30,#30,#28,.T.);
#32=ORIENTED_EDGE('',*,*,#31,.F.);
#33=EDGE_LOOP('',(#32));
#34=FACE_BOUND('',#33,.T.);
#35=CARTESIAN_POINT('',(1.6764,-15.8182667849547,1.1811));
#36=CARTESIAN_POINT('',(1.74264416873393,-15.8182673710236,1.18109709610591));
#37=CARTESIAN_POINT('',(1.8089340286671,-15.8186873913078,1.17550812098305));
#38=CARTESIAN_POINT('',(1.93968131348669,-15.8203221715723,1.15329394689385));
#39=CARTESIAN_POINT('',(2.00413654741269,-15.8215378433448,1.13665608592309));
#40=CARTESIAN_POINT('',(2.12930188939444,-15.8246254736938,1.09282647160235));
#41=CARTESIAN_POINT('',(2.19001403204529,-15.8264970719697,1.06564051144943));
#42=CARTESIAN_POINT('',(2.30599821993871,-15.8306852185627,1.00149629746544));
#43=CARTESIAN_POINT('',(2.36127146254117,-15.8330016686139,0.964540201139107));
#44=CARTESIAN_POINT('',(2.46493873737729,-15.8378239270416,0.881821420175578));
#45=CARTESIAN_POINT('',(2.51331993857455,-15.8403300756415,0.836042673482492));
#46=CARTESIAN_POINT('',(2.60171969620121,-15.8452462147453,0.73701177873509));
#47=CARTESIAN_POINT('',(2.64173789497225,-15.8476562011332,0.683759311216822));
#48=CARTESIAN_POINT('',(2.71231713719341,-15.8521115899929,0.571217637469297));
#49=CARTESIAN_POINT('',(2.74286726365956,-15.8541565704582,0.511921566643991));
#50=CARTESIAN_POINT('',(2.79357330697215,-15.8576478951142,0.389023880259087));
#51=CARTESIAN_POINT('',(2.81372937313569,-15.8590942479045,0.325422326565259));
#52=CARTESIAN_POINT('',(2.84303871183067,-15.8612229835492,0.195845281241369));
#53=CARTESIAN_POINT('',(2.85221249758298,-15.8619067905583,0.129874453310533));
#54=CARTESIAN_POINT('',(2.85936024969628,-15.8624382017871,-0.00267395529183814));
#55=CARTESIAN_POINT('',(2.85733438657112,-15.8622858187377,-0.0692515267103384));
#56=CARTESIAN_POINT('',(2.84215718717828,-15.8611632001951,-0.200984508135482));
#57=CARTESIAN_POINT('',(2.82902791212068,-15.8601945864726,-0.266142475594516));
#58=CARTESIAN_POINT('',(2.79205085309891,-15.8575503661136,-0.393327222917449));
#59=CARTESIAN_POINT('',(2.76820298475277,-15.8558747539114,-0.45535397812665));
#60=CARTESIAN_POINT('',(2.7104409229413,-15.8520023217798,-0.574586080576998));
#61=CARTESIAN_POINT('',(2.67651679509682,-15.849804987906,-0.631786597734933));
#62=CARTESIAN_POINT('',(2.59957241324594,-15.845136212562,-0.739689782330418));
#63=CARTESIAN_POINT('',(2.55655201255239,-15.8426647666718,-0.790392344960316));
#64=CARTESIAN_POINT('',(2.46251181826335,-15.8377186193713,-0.883989245816354));
#65=CARTESIAN_POINT('',(2.41147286485323,-15.835243924616,-0.926864336179001));
#66=CARTESIAN_POINT('',(2.30291130687446,-15.8305762571027,-1.00344066130214));
#67=CARTESIAN_POINT('',(2.24538869839128,-15.8283832845148,-1.03714189052383));
#68=CARTESIAN_POINT('',(2.12547975943296,-15.824526845607,-1.09441281325491));
#69=CARTESIAN_POINT('',(2.06309299168828,-15.8228634269604,-1.11798159465209));
#70=CARTESIAN_POINT('',(1.93523272446878,-15.820255252729,-1.15430478469924));
#71=CARTESIAN_POINT('',(1.86975927668542,-15.8193104851136,-1.16705937438253));
#72=CARTESIAN_POINT('',(1.73775238123142,-15.8182484333402,-1.1813679369294));
#73=CARTESIAN_POINT('',(1.67122185392751,-15.8181291691189,-1.18294871164589));
#74=CARTESIAN_POINT('',(1.53884156213158,-15.818726396185,-1.17493489608492));
#75=CARTESIAN_POINT('',(1.47299179259051,-15.8194428812694,-1.16534038875247));
#76=CARTESIAN_POINT('',(1.34391865984863,-15.8216290652963,-1.1352706688289));
#77=CARTESIAN_POINT('',(1.28069238456379,-15.8230979035589,-1.11480788838172));
#78=CARTESIAN_POINT('',(1.15857094257284,-15.8266225624768,-1.06359510173224));
#79=CARTESIAN_POINT('',(1.09967583153131,-15.8286783906744,-1.03284496334389));
#80=CARTESIAN_POINT('',(0.987765670291761,-15.8331501796947,-0.961862214896855));
#81=CARTESIAN_POINT('',(0.934762004799442,-15.8355668173467,-0.92161169918259));
#82=CARTESIAN_POINT('',(0.83625420271908,-15.8404855927841,-0.832796712176071));
#83=CARTESIAN_POINT('',(0.790750169476208,-15.8429877317473,-0.784232126334463));
#84=CARTESIAN_POINT('',(0.708442277450886,-15.8478014230544,-0.680051963561503));
#85=CARTESIAN_POINT('',(0.67165580020937,-15.8501125887512,-0.624422633978131));
#86=CARTESIAN_POINT('',(0.607946363044107,-15.8542783625327,-0.507760906668558));
#87=CARTESIAN_POINT('',(0.581023321778104,-15.8561329743826,-0.446728553505425));
#88=CARTESIAN_POINT('',(0.537835031995909,-15.8591748690681,-0.32105629004593));
#89=CARTESIAN_POINT('',(0.521558919197051,-15.8603628319855,-0.256420130469261));
#90=CARTESIAN_POINT('',(0.500090975752834,-15.8619403178887,-0.125323275144136));
#91=CARTESIAN_POINT('',(0.494898981780118,-15.8623298526395,-0.0588626062949124));
#92=CARTESIAN_POINT('',(0.495748400249284,-15.8622666193348,0.0738250511872975));
#93=CARTESIAN_POINT('',(0.501762673451791,-15.8618158862312,0.140052216225332));
#94=CARTESIAN_POINT('',(0.524797456256612,-15.8601268073418,0.270553319375336));
#95=CARTESIAN_POINT('',(0.541817983072967,-15.8588884603241,0.334827254432242));
#96=CARTESIAN_POINT('',(0.58637555073111,-15.8557632049431,0.459600156069351));
#97=CARTESIAN_POINT('',(0.613912262833064,-15.8538763168535,0.520099240584005));
#98=CARTESIAN_POINT('',(0.678717210101999,-15.849665424135,0.635619686929459));
#99=CARTESIAN_POINT('',(0.715985246224897,-15.8473414284469,0.690641160767282));
#100=CARTESIAN_POINT('',(0.799296429579958,-15.8425107315879,0.793783061673632));
#101=CARTESIAN_POINT('',(0.84535951698454,-15.8400036233967,0.841887363048968));
#102=CARTESIAN_POINT('',(0.944920198985949,-15.8350926820801,0.929699270998159));
#103=CARTESIAN_POINT('',(0.998419599779503,-15.8326888742314,0.969404831686148));
#104=CARTESIAN_POINT('',(1.11141818484063,-15.8282525424126,1.03933452119939));
#105=CARTESIAN_POINT('',(1.17092670409376,-15.8262206103495,1.06954358855669));
#106=CARTESIAN_POINT('',(1.29414457713297,-15.8227654492962,1.11950336819377));
#107=CARTESIAN_POINT('',(1.35784896249396,-15.8213415148034,1.13926620834273));
#108=CARTESIAN_POINT('',(1.46434643641278,-15.8196330057175,1.16269147352801));
#109=CARTESIAN_POINT('',(1.50645292085167,-15.8191229976438,1.16958561031147));
#110=CARTESIAN_POINT('',(1.59116663134516,-15.8184396990513,1.17879080309823));
#111=CARTESIAN_POINT('',(1.63377385636516,-15.8182664078368,1.1811018685691));
#112=CARTESIAN_POINT('',(1.6764,-15.8182667849547,1.1811));
#113=B_SPLINE_CURVE_WITH_KNOTS('',3,(#35,#36,#37,#38,#39,#40,#41,#42,#43,#44,#45,#46,#47,#48,
#49,#50,#51,#52,#53,#54,#55,#56,#57,#58,#59,#60,#61,#62,#63,#64,#65,#66,#67,#68,#69,#70,#71,#72,
#73,#74,#75,#76,#77,#78,#79,#80,#81,#82,#83,#84,#85,#86,#87,#88,#89,#90,#91,#92,#93,#94,#95,#96,
#97,#98,#99,#100,#101,#102,#103,#104,#105,#106,#107,#108,#109,#110,#111,#112),.UNSPECIFIED.,.T.,
.F.,(4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,
0.198576881508568,0.397381725407248,0.596077536478999,0.794729506852428,0.993746608557803,
1.19277221983509,1.39202646736354,1.59127785240191,1.79015648271511,1.98903208512335,
2.18751347028613,2.38599641801808,2.5846757071791,2.78335820050075,2.98252286288507,
3.18168764551659,3.38087035299858,3.58004972602712,3.7787511787233,3.97745115663009,
4.17592433095927,4.37440005564143,4.57325288350966,4.77210845134714,4.97135723372447,
5.17060437289043,5.36964787886507,5.56868845186198,5.76724761655921,5.96580709180843,
6.16436036052318,6.36290956835601,6.56191439087104,6.76096763415442,6.96033500206828,
7.1594703970668,7.28724895209186,7.41502724315533),.UNSPECIFIED.);
#114=CARTESIAN_POINT('',(1.6764,-15.8182667849547,1.1811));
#115=VERTEX_POINT('',#114);
#116=EDGE_CURVE('E49',#115,#115,#113,.T.);
#117=ORIENTED_EDGE('',*,*,#116,.T.);
#118=EDGE_LOOP('',(#117));
#119=FACE_BOUND('',#118,.T.);
#120=CARTESIAN_POINT('',(1.6764,15.8182667849547,1.1811));
#121=CARTESIAN_POINT('',(1.61015583126607,15.8182673710236,1.18109709610591));
#122=CARTESIAN_POINT('',(1.5438659713329,15.8186873913078,1.17550812098305));
#123=CARTESIAN_POINT('',(1.4131186865133,15.8203221715723,1.15329394689385));
#124=CARTESIAN_POINT('',(1.34866345258731,15.8215378433448,1.13665608592309));
#125=CARTESIAN_POINT('',(1.22349811060555,15.8246254736938,1.09282647160235));
#126=CARTESIAN_POINT('',(1.1627859679547,15.8264970719697,1.06564051144943));
#127=CARTESIAN_POINT('',(1.04680178006129,15.8306852185627,1.00149629746544));
#128=CARTESIAN_POINT('',(0.991528537458829,15.8330016686139,0.964540201139107));
#129=CARTESIAN_POINT('',(0.887861262622709,15.8378239270416,0.881821420175578));
#130=CARTESIAN_POINT('',(0.839480061425446,15.8403300756415,0.836042673482492));
#131=CARTESIAN_POINT('',(0.751080303798785,15.8452462147453,0.737011778735089));
#132=CARTESIAN_POINT('',(0.71106210502775,15.8476562011332,0.683759311216821));
#133=CARTESIAN_POINT('',(0.640482862806582,15.8521115899929,0.571217637469297));
#134=CARTESIAN_POINT('',(0.609932736340436,15.8541565704582,0.511921566643991));
#135=CARTESIAN_POINT('',(0.559226693027845,15.8576478951142,0.389023880259087));
#136=CARTESIAN_POINT('',(0.539070626864303,15.8590942479045,0.325422326565259));
#137=CARTESIAN_POINT('',(0.509761288169328,15.8612229835492,0.195845281241369));
#138=CARTESIAN_POINT('',(0.500587502417011,15.8619067905583,0.129874453310533));
#139=CARTESIAN_POINT('',(0.493439750303721,15.8624382017871,-0.00267395529183815));
#140=CARTESIAN_POINT('',(0.495465613428873,15.8622858187377,-0.0692515267103384));
#141=CARTESIAN_POINT('',(0.510642812821714,15.8611632001951,-0.200984508135482));
#142=CARTESIAN_POINT('',(0.523772087879318,15.8601945864726,-0.266142475594516));
#143=CARTESIAN_POINT('',(0.560749146901088,15.8575503661136,-0.393327222917449));
#144=CARTESIAN_POINT('',(0.584597015247224,15.8558747539114,-0.45535397812665));
#145=CARTESIAN_POINT('',(0.642359077058698,15.8520023217798,-0.574586080576998));
#146=CARTESIAN_POINT('',(0.676283204903172,15.849804987906,-0.631786597734933));
#147=CARTESIAN_POINT('',(0.753227586754055,15.845136212562,-0.739689782330418));
#148=CARTESIAN_POINT('',(0.796247987447603,15.8426647666718,-0.790392344960316));
#149=CARTESIAN_POINT('',(0.890288181736649,15.8377186193713,-0.883989245816354));
#150=CARTESIAN_POINT('',(0.941327135146767,15.835243924616,-0.926864336179001));
#151=CARTESIAN_POINT('',(1.04988869312553,15.8305762571027,-1.00344066130214));
#152=CARTESIAN_POINT('',(1.10741130160872,15.8283832845148,-1.03714189052383));
#153=CARTESIAN_POINT('',(1.22732024056704,15.824526845607,-1.09441281325491));
#154=CARTESIAN_POINT('',(1.28970700831171,15.8228634269604,-1.11798159465209));
#155=CARTESIAN_POINT('',(1.41756727553122,15.820255252729,-1.15430478469924));
#156=CARTESIAN_POINT('',(1.48304072331458,15.8193104851136,-1.16705937438253));
#157=CARTESIAN_POINT('',(1.61504761876858,15.8182484333402,-1.1813679369294));
#158=CARTESIAN_POINT('',(1.68157814607249,15.8181291691189,-1.18294871164589));
#159=CARTESIAN_POINT('',(1.81395843786842,15.818726396185,-1.17493489608492));
#160=CARTESIAN_POINT('',(1.87980820740948,15.8194428812694,-1.16534038875247));
#161=CARTESIAN_POINT('',(2.00888134015137,15.8216290652963,-1.1352706688289));
#162=CARTESIAN_POINT('',(2.07210761543621,15.8230979035589,-1.11480788838172));
#163=CARTESIAN_POINT('',(2.19422905742716,15.8266225624768,-1.06359510173224));
#164=CARTESIAN_POINT('',(2.25312416846868,15.8286783906744,-1.03284496334389));
#165=CARTESIAN_POINT('',(2.36503432970824,15.8331501796947,-0.961862214896855));
#166=CARTESIAN_POINT('',(2.41803799520055,15.8355668173467,-0.92161169918259));
#167=CARTESIAN_POINT('',(2.51654579728092,15.8404855927841,-0.832796712176071));
#168=CARTESIAN_POINT('',(2.56204983052379,15.8429877317473,-0.784232126334463));
#169=CARTESIAN_POINT('',(2.64435772254911,15.8478014230544,-0.680051963561504));
#170=CARTESIAN_POINT('',(2.68114419979063,15.8501125887512,-0.624422633978131));
#171=CARTESIAN_POINT('',(2.74485363695589,15.8542783625327,-0.507760906668558));
#172=CARTESIAN_POINT('',(2.77177667822189,15.8561329743826,-0.446728553505425));
#173=CARTESIAN_POINT('',(2.81496496800409,15.8591748690681,-0.32105629004593));
#174=CARTESIAN_POINT('',(2.83124108080295,15.8603628319855,-0.25642013046926));
#175=CARTESIAN_POINT('',(2.85270902424716,15.8619403178887,-0.125323275144136));
#176=CARTESIAN_POINT('',(2.85790101821988,15.8623298526395,-0.0588626062949123));
#177=CARTESIAN_POINT('',(2.85705159975071,15.8622666193348,0.0738250511872975));
#178=CARTESIAN_POINT('',(2.85103732654821,15.8618158862312,0.140052216225333));
#179=CARTESIAN_POINT('',(2.82800254374338,15.8601268073418,0.270553319375336));
#180=CARTESIAN_POINT('',(2.81098201692703,15.8588884603241,0.334827254432242));
#181=CARTESIAN_POINT('',(2.76642444926889,15.8557632049431,0.459600156069351));
#182=CARTESIAN_POINT('',(2.73888773716693,15.8538763168535,0.520099240584005));
#183=CARTESIAN_POINT('',(2.674082789898,15.849665424135,0.635619686929459));
#184=CARTESIAN_POINT('',(2.6368147537751,15.8473414284469,0.690641160767282));
#185=CARTESIAN_POINT('',(2.55350357042004,15.8425107315879,0.793783061673632));
#186=CARTESIAN_POINT('',(2.50744048301546,15.8400036233967,0.841887363048967));
#187=CARTESIAN_POINT('',(2.40787980101405,15.8350926820801,0.929699270998158));
#188=CARTESIAN_POINT('',(2.35438040022049,15.8326888742314,0.969404831686148));
#189=CARTESIAN_POINT('',(2.24138181515936,15.8282525424126,1.03933452119939));
#190=CARTESIAN_POINT('',(2.18187329590624,15.8262206103495,1.06954358855669));
#191=CARTESIAN_POINT('',(2.05865542286703,15.8227654492962,1.11950336819377));
#192=CARTESIAN_POINT('',(1.99495103750603,15.8213415148034,1.13926620834273));
#193=CARTESIAN_POINT('',(1.88845356358722,15.8196330057175,1.16269147352801));
#194=CARTESIAN_POINT('',(1.84634707914832,15.8191229976438,1.16958561031147));
#195=CARTESIAN_POINT('',(1.76163336865483,15.8184396990513,1.17879080309823));
#196=CARTESIAN_POINT('',(1.71902614363483,15.8182664078368,1.1811018685691));
#197=CARTESIAN_POINT('',(1.6764,15.8182667849547,1.1811));
#198=B_SPLINE_CURVE_WITH_KNOTS('',3,(#120,#121,#122,#123,#124,#125,#126,#127,#128,#129,#130,
#131,#132,#133,#134,#135,#136,#137,#138,#139,#140,#141,#142,#143,#144,#145,#146,#147,#148,#149,
#150,#151,#152,#153,#154,#155,#156,#157,#158,#159,#160,#161,#162,#163,#164,#165,#166,#167,#168,
#169,#170,#171,#172,#173,#174,#175,#176,#177,#178,#179,#180,#181,#182,#183,#184,#185,#186,#187,
#188,#189,#190,#191,#192,#193,#194,#195,#196,#197),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.198576881508568,
0.397381725407248,0.596077536479,0.794729506852428,0.993746608557803,1.19277221983509,
1.39202646736354,1.59127785240191,1.79015648271511,1.98903208512335,2.18751347028613,
2.38599641801808,2.5846757071791,2.78335820050075,2.98252286288507,3.18168764551659,
3.38087035299858,3.58004972602712,3.7787511787233,3.97745115663009,4.17592433095927,
4.37440005564143,4.57325288350966,4.77210845134714,4.97135723372447,5.17060437289043,
5.36964787886507,5.56868845186198,5.76724761655921,5.96580709180843,6.16436036052318,
6.36290956835601,6.56191439087104,6.76096763415442,6.96033500206828,7.1594703970668,
7.28724895209186,7.41502724315534),.UNSPECIFIED.);
#199=CARTESIAN_POINT('',(1.6764,15.8182667849547,1.1811));
#200=VERTEX_POINT('',#199);
#201=EDGE_CURVE('E57',#200,#200,#198,.T.);
#202=ORIENTED_EDGE('',*,*,#201,.T.);
#203=EDGE_LOOP('',(#202));
#204=FACE_BOUND('',#203,.T.);
#205=CARTESIAN_POINT('',(4.2681772846325,0.,0.));
#206=DIRECTION('',(1.,0.,0.));
#207=DIRECTION('',(0.,0.,-1.));
#208=AXIS2_PLACEMENT_3D('',#205,#206,#207);
#209=CIRCLE('',#208,15.8623);
#210=CARTESIAN_POINT('',(4.2681772846325,0.,-15.8623));
#211=VERTEX_POINT('',#210);
#212=EDGE_CURVE('E10',#211,#211,#209,.T.);
#213=ORIENTED_EDGE('',*,*,#212,.F.);
#214=EDGE_LOOP('',(#213));
#215=FACE_BOUND('',#214,.T.);
#216=ADVANCED_FACE('F31',(#34,#119,#204,#215),#23,.T.);
#217=CARTESIAN_POINT('',(0.,0.,0.));
#218=DIRECTION('',(-1.,0.,0.));
#219=DIRECTION('',(0.,0.,1.));
#220=AXIS2_PLACEMENT_3D('',#217,#218,#219);
#221=CYLINDRICAL_SURFACE('',#220,15.3543);
#222=CARTESIAN_POINT('',(9.32630715072046,0.,0.));
#223=DIRECTION('',(-1.,0.,0.));
#224=DIRECTION('',(0.,0.,1.));
#225=AXIS2_PLACEMENT_3D('',#222,#223,#224);
#226=CIRCLE('',#225,15.3543);
#227=CARTESIAN_POINT('',(9.32630715072046,0.,15.3543));
#228=VERTEX_POINT('',#227);
#229=EDGE_CURVE('E207',#228,#228,#226,.T.);
#230=ORIENTED_EDGE('',*,*,#229,.F.);
#231=EDGE_LOOP('',(#230));
#232=FACE_BOUND('',#231,.T.);
#233=CARTESIAN_POINT('',(10.2362,0.,0.));
#234=DIRECTION('',(1.,0.,0.));
#235=DIRECTION('',(0.,0.,-1.));
#236=AXIS2_PLACEMENT_3D('',#233,#234,#235);
#237=CIRCLE('',#236,15.3543);
#238=CARTESIAN_POINT('',(10.2362,0.,-15.3543));
#239=VERTEX_POINT('',#238);
#240=EDGE_CURVE('E42',#239,#239,#237,.T.);
#241=ORIENTED_EDGE('',*,*,#240,.F.);
#242=EDGE_LOOP('',(#241));
#243=FACE_BOUND('',#242,.T.);
#244=ADVANCED_FACE('F122',(#232,#243),#221,.T.);
#245=CARTESIAN_POINT('',(11.557,0.,0.));
#246=DIRECTION('',(-1.,0.,0.));
#247=DIRECTION('',(0.,0.,1.));
#248=AXIS2_PLACEMENT_3D('',#245,#246,#247);
#249=CIRCLE('',#248,15.3543);
#250=CARTESIAN_POINT('',(11.557,0.,15.3543));
#251=VERTEX_POINT('',#250);
#252=EDGE_CURVE('E168',#251,#251,#249,.T.);
#253=ORIENTED_EDGE('',*,*,#252,.T.);
#254=EDGE_LOOP('',(#253));
#255=FACE_BOUND('',#254,.T.);
#256=CARTESIAN_POINT('',(11.4808,0.,0.));
#257=DIRECTION('',(-1.,0.,0.));
#258=DIRECTION('',(0.,0.,1.));
#259=AXIS2_PLACEMENT_3D('',#256,#257,#258);
#260=CIRCLE('',#259,15.3543);
#261=CARTESIAN_POINT('',(11.4808,0.,15.3543));
#262=VERTEX_POINT('',#261);
#263=EDGE_CURVE('E46',#262,#262,#260,.T.);
#264=ORIENTED_EDGE('',*,*,#263,.F.);
#265=EDGE_LOOP('',(#264));
#266=FACE_BOUND('',#265,.T.);
#267=ADVANCED_FACE('F127',(#255,#266),#221,.T.);
#268=CARTESIAN_POINT('',(8.001,0.,0.));
#269=DIRECTION('',(-1.,0.,0.));
#270=DIRECTION('',(0.,0.,1.));
#271=AXIS2_PLACEMENT_3D('',#268,#269,#270);
#272=CIRCLE('',#271,15.3543);
#273=CARTESIAN_POINT('',(8.001,0.,15.3543));
#274=VERTEX_POINT('',#273);
#275=EDGE_CURVE('E159',#274,#274,#272,.T.);
#276=ORIENTED_EDGE('',*,*,#275,.F.);
#277=EDGE_LOOP('',(#276));
#278=FACE_BOUND('',#277,.T.);
#279=CARTESIAN_POINT('',(8.60609284927954,0.,0.));
#280=DIRECTION('',(1.,0.,0.));
#281=DIRECTION('',(0.,0.,-1.));
#282=AXIS2_PLACEMENT_3D('',#279,#280,#281);
#283=CIRCLE('',#282,15.3543);
#284=CARTESIAN_POINT('',(8.60609284927954,0.,-15.3543));
#285=VERTEX_POINT('',#284);
#286=EDGE_CURVE('E210',#285,#285,#283,.T.);
#287=ORIENTED_EDGE('',*,*,#286,.F.);
#288=EDGE_LOOP('',(#287));
#289=FACE_BOUND('',#288,.T.);
#290=ADVANCED_FACE('F130',(#278,#289),#221,.T.);
#291=CARTESIAN_POINT('',(0.,0.,0.));
#292=DIRECTION('',(-1.,0.,0.));
#293=DIRECTION('',(0.,0.,1.));
#294=AXIS2_PLACEMENT_3D('',#291,#292,#293);
#295=CYLINDRICAL_SURFACE('',#294,15.3543);
#296=CARTESIAN_POINT('',(-9.271,0.,0.));
#297=DIRECTION('',(-1.,0.,0.));
#298=DIRECTION('',(0.,0.,1.));
#299=AXIS2_PLACEMENT_3D('',#296,#297,#298);
#300=CIRCLE('',#299,15.3543);
#301=CARTESIAN_POINT('',(-9.271,0.,15.3543));
#302=VERTEX_POINT('',#301);
#303=EDGE_CURVE('E195',#302,#302,#300,.T.);
#304=ORIENTED_EDGE('',*,*,#303,.F.);
#305=EDGE_LOOP('',(#304));
#306=FACE_BOUND('',#305,.T.);
#307=CARTESIAN_POINT('',(-8.36110715072046,0.,0.));
#308=DIRECTION('',(1.,0.,0.));
#309=DIRECTION('',(0.,0.,-1.));
#310=AXIS2_PLACEMENT_3D('',#307,#308,#309);
#311=CIRCLE('',#310,15.3543);
#312=CARTESIAN_POINT('',(-8.36110715072046,0.,-15.3543));
#313=VERTEX_POINT('',#312);
#314=EDGE_CURVE('E204',#313,#313,#311,.T.);
#315=ORIENTED_EDGE('',*,*,#314,.F.);
#316=EDGE_LOOP('',(#315));
#317=FACE_BOUND('',#316,.T.);
#318=ADVANCED_FACE('F222',(#306,#317),#295,.T.);
#319=CARTESIAN_POINT('',(-7.0358,0.,0.));
#320=DIRECTION('',(-1.,0.,0.));
#321=DIRECTION('',(0.,0.,1.));
#322=AXIS2_PLACEMENT_3D('',#319,#320,#321);
#323=CIRCLE('',#322,15.3543);
#324=CARTESIAN_POINT('',(-7.0358,0.,15.3543));
#325=VERTEX_POINT('',#324);
#326=EDGE_CURVE('E162',#325,#325,#323,.T.);
#327=ORIENTED_EDGE('',*,*,#326,.T.);
#328=EDGE_LOOP('',(#327));
#329=FACE_BOUND('',#328,.T.);
#330=CARTESIAN_POINT('',(-7.64089284927953,0.,0.));
#331=DIRECTION('',(-1.,0.,0.));
#332=DIRECTION('',(0.,0.,1.));
#333=AXIS2_PLACEMENT_3D('',#330,#331,#332);
#334=CIRCLE('',#333,15.3543);
#335=CARTESIAN_POINT('',(-7.64089284927953,0.,15.3543));
#336=VERTEX_POINT('',#335);
#337=EDGE_CURVE('E201',#336,#336,#334,.T.);
#338=ORIENTED_EDGE('',*,*,#337,.F.);
#339=EDGE_LOOP('',(#338));
#340=FACE_BOUND('',#339,.T.);
#341=ADVANCED_FACE('F270',(#329,#340),#295,.T.);
#342=CARTESIAN_POINT('',(-10.5918,0.,0.));
#343=DIRECTION('',(-1.,0.,0.));
#344=DIRECTION('',(0.,0.,1.));
#345=AXIS2_PLACEMENT_3D('',#342,#343,#344);
#346=CIRCLE('',#345,15.3543);
#347=CARTESIAN_POINT('',(-10.5918,0.,15.3543));
#348=VERTEX_POINT('',#347);
#349=EDGE_CURVE('E259',#348,#348,#346,.T.);
#350=ORIENTED_EDGE('',*,*,#349,.F.);
#351=EDGE_LOOP('',(#350));
#352=FACE_BOUND('',#351,.T.);
#353=CARTESIAN_POINT('',(-10.5156,0.,0.));
#354=DIRECTION('',(1.,0.,0.));
#355=DIRECTION('',(0.,0.,-1.));
#356=AXIS2_PLACEMENT_3D('',#353,#354,#355);
#357=CIRCLE('',#356,15.3543);
#358=CARTESIAN_POINT('',(-10.5156,0.,-15.3543));
#359=VERTEX_POINT('',#358);
#360=EDGE_CURVE('E198',#359,#359,#357,.T.);
#361=ORIENTED_EDGE('',*,*,#360,.F.);
#362=EDGE_LOOP('',(#361));
#363=FACE_BOUND('',#362,.T.);
#364=ADVANCED_FACE('F104',(#352,#363),#295,.T.);
#365=CARTESIAN_POINT('',(0.,0.,0.));
#366=DIRECTION('',(-1.,0.,0.));
#367=DIRECTION('',(0.,0.,1.));
#368=AXIS2_PLACEMENT_3D('',#365,#366,#367);
#369=CYLINDRICAL_SURFACE('',#368,6.35);
#370=CARTESIAN_POINT('',(0.355599999999999,0.,0.));
#371=DIRECTION('',(-1.,0.,0.));
#372=DIRECTION('',(0.,0.,1.));
#373=AXIS2_PLACEMENT_3D('',#370,#371,#372);
#374=CIRCLE('',#373,6.35);
#375=CARTESIAN_POINT('',(0.355599999999999,0.,6.35));
#376=VERTEX_POINT('',#375);
#377=EDGE_CURVE('E180',#376,#376,#374,.T.);
#378=ORIENTED_EDGE('',*,*,#377,.F.);
#379=EDGE_LOOP('',(#378));
#380=FACE_BOUND('',#379,.T.);
#381=CARTESIAN_POINT('',(-15.748,0.,0.));
#382=DIRECTION('',(-1.,0.,0.));
#383=DIRECTION('',(0.,0.,1.));
#384=AXIS2_PLACEMENT_3D('',#381,#382,#383);
#385=CIRCLE('',#384,6.35);
#386=CARTESIAN_POINT('',(-15.748,0.,6.35));
#387=VERTEX_POINT('',#386);
#388=EDGE_CURVE('E253',#387,#387,#385,.T.);
#389=ORIENTED_EDGE('',*,*,#388,.T.);
#390=EDGE_LOOP('',(#389));
#391=FACE_BOUND('',#390,.T.);
#392=ADVANCED_FACE('F101',(#380,#391),#369,.F.);
#393=CARTESIAN_POINT('',(0.355599999999999,6.35,0.));
#394=DIRECTION('',(-1.,0.,0.));
#395=DIRECTION('',(0.,0.,1.));
#396=AXIS2_PLACEMENT_3D('',#393,#394,#395);
#397=PLANE('',#396);
#398=CARTESIAN_POINT('',(0.355599999999999,0.,0.));
#399=DIRECTION('',(-1.,0.,0.));
#400=DIRECTION('',(0.,0.,1.));
#401=AXIS2_PLACEMENT_3D('',#398,#399,#400);
#402=CIRCLE('',#401,12.7);
#403=CARTESIAN_POINT('',(0.355599999999999,0.,12.7));
#404=VERTEX_POINT('',#403);
#405=EDGE_CURVE('E177',#404,#404,#402,.T.);
#406=ORIENTED_EDGE('',*,*,#405,.F.);
#407=EDGE_LOOP('',(#406));
#408=FACE_BOUND('',#407,.T.);
#409=ORIENTED_EDGE('',*,*,#377,.T.);
#410=EDGE_LOOP('',(#409));
#411=FACE_BOUND('',#410,.T.);
#412=ADVANCED_FACE('F95',(#408,#411),#397,.F.);
#413=CARTESIAN_POINT('',(0.,0.,0.));
#414=DIRECTION('',(-1.,0.,0.));
#415=DIRECTION('',(0.,0.,1.));
#416=AXIS2_PLACEMENT_3D('',#413,#414,#415);
#417=CYLINDRICAL_SURFACE('',#416,12.7);
#418=CARTESIAN_POINT('',(1.6764,-12.644959580402,1.1811));
#419=CARTESIAN_POINT('',(1.61021118952509,-12.6449603052943,1.18109712176843));
#420=CARTESIAN_POINT('',(1.54397804150864,-12.6454848668838,1.17551744194701));
#421=CARTESIAN_POINT('',(1.41334642293007,-12.6475262641686,1.15334235555994));
#422=CARTESIAN_POINT('',(1.34895008314637,-12.6490442069825,1.13673465801948));
#423=CARTESIAN_POINT('',(1.22390284293175,-12.6528989713156,1.09298985533183));
#424=CARTESIAN_POINT('',(1.1632497613033,-12.6552353105536,1.06585895050645));
#425=CARTESIAN_POINT('',(1.0473720677673,-12.6604630234231,1.0018494103816));
#426=CARTESIAN_POINT('',(0.992146344536677,-12.6633542830678,0.964972776377593));
#427=CARTESIAN_POINT('',(0.88850261312299,-12.6693763199196,0.882392964786676));
#428=CARTESIAN_POINT('',(0.840104171950573,-12.6725077473809,0.836665274263883));
#429=CARTESIAN_POINT('',(0.751657189053127,-12.6786513632269,0.737733579896172));
#430=CARTESIAN_POINT('',(0.711609021675114,-12.6816635462609,0.684529241048222));
#431=CARTESIAN_POINT('',(0.640932756820331,-12.687235603915,0.572035879025251));
#432=CARTESIAN_POINT('',(0.610321827075122,-12.6897946506567,0.512736025373325));
#433=CARTESIAN_POINT('',(0.559498787371294,-12.6941650514623,0.389810284938741));
#434=CARTESIAN_POINT('',(0.539286455576083,-12.6959764214764,0.326184490475538));
#435=CARTESIAN_POINT('',(0.509891342678619,-12.6986428199913,0.196609569577913));
#436=CARTESIAN_POINT('',(0.50067660528974,-12.6995006188334,0.130667750594228));
#437=CARTESIAN_POINT('',(0.493439415065252,-12.7001726325272,-0.00183171458629484));
#438=CARTESIAN_POINT('',(0.495416708273271,-12.6999868710582,-0.0683893467756106));
#439=CARTESIAN_POINT('',(0.510481425610212,-12.6985949696696,-0.200014289064133));
#440=CARTESIAN_POINT('',(0.523534486685449,-12.6973919857671,-0.265085570105092));
#441=CARTESIAN_POINT('',(0.560326722935315,-12.6941045119793,-0.392109686661056));
#442=CARTESIAN_POINT('',(0.584066020694326,-12.6920200119818,-0.454062486394152));
#443=CARTESIAN_POINT('',(0.641594810600635,-12.6871984987081,-0.573199801152148));
#444=CARTESIAN_POINT('',(0.675399589984239,-12.6844604941672,-0.630376892564855));
#445=CARTESIAN_POINT('',(0.752088650118719,-12.6786394057851,-0.738258729949108));
#446=CARTESIAN_POINT('',(0.794973160895775,-12.6755563132024,-0.788963311893736));
#447=CARTESIAN_POINT('',(0.888797791894876,-12.6693774829036,-0.882661927585866));
#448=CARTESIAN_POINT('',(0.939767790136505,-12.6662817414975,-0.925626048502373));
#449=CARTESIAN_POINT('',(1.04821271943278,-12.6604382081042,-1.00239277882805));
#450=CARTESIAN_POINT('',(1.1056876579615,-12.6576904165169,-1.03619537771064));
#451=CARTESIAN_POINT('',(1.2255330759683,-12.6528535396737,-1.09367894797377));
#452=CARTESIAN_POINT('',(1.28790438387025,-12.6507645661854,-1.11735820218344));
#453=CARTESIAN_POINT('',(1.41576128198234,-12.6474841192613,-1.15389991970517));
#454=CARTESIAN_POINT('',(1.48124679031771,-12.6462926222441,-1.16676266722568));
#455=CARTESIAN_POINT('',(1.61321097047128,-12.6449460149639,-1.18126803715863));
#456=CARTESIAN_POINT('',(1.67968501116331,-12.644787044789,-1.18295244824286));
#457=CARTESIAN_POINT('',(1.81196957014007,-12.6455133046085,-1.17516295293092));
#458=CARTESIAN_POINT('',(1.87778009615055,-12.6463985224304,-1.16568917660882));
#459=CARTESIAN_POINT('',(2.00674851267632,-12.6491099023827,-1.1358871397878));
#460=CARTESIAN_POINT('',(2.06991098171745,-12.6509343612968,-1.11557852473258));
#461=CARTESIAN_POINT('',(2.1919324361149,-12.655317259616,-1.0647033158799));
#462=CARTESIAN_POINT('',(2.25079133583737,-12.6578757136214,-1.03413651802934));
#463=CARTESIAN_POINT('',(2.36272567147472,-12.6634476814418,-0.963507470662524));
#464=CARTESIAN_POINT('',(2.41578352422562,-12.6664625161162,-0.923417460793641));
#465=CARTESIAN_POINT('',(2.51443160619507,-12.6726031662766,-0.834919920463822));
#466=CARTESIAN_POINT('',(2.56002167549524,-12.6757289841374,-0.786512211929531));
#467=CARTESIAN_POINT('',(2.64258351520941,-12.6817509844255,-0.682572413844799));
#468=CARTESIAN_POINT('',(2.67952807297362,-12.6846464233266,-0.627018659598214));
#469=CARTESIAN_POINT('',(2.74356315142806,-12.6898706541552,-0.510471158452592));
#470=CARTESIAN_POINT('',(2.77065379114829,-12.6921994529272,-0.449477477276008));
#471=CARTESIAN_POINT('',(2.81416564360736,-12.6960246268698,-0.323877611901054));
#472=CARTESIAN_POINT('',(2.83060346524986,-12.6975222973335,-0.25927722260895));
#473=CARTESIAN_POINT('',(2.85239731263923,-12.6995217595164,-0.1282188092889));
#474=CARTESIAN_POINT('',(2.85775360482499,-12.7000235751794,-0.0617608299628832));
#475=CARTESIAN_POINT('',(2.85722888875374,-12.6999747966921,0.0708585612708288));
#476=CARTESIAN_POINT('',(2.85139019746039,-12.6994281656607,0.137020146156616));
#477=CARTESIAN_POINT('',(2.82872977306015,-12.6973517366295,0.267418470714384));
#478=CARTESIAN_POINT('',(2.81190802832098,-12.6958219375885,0.331655208347658));
#479=CARTESIAN_POINT('',(2.76777031394872,-12.6919506766174,0.456381395331926));
#480=CARTESIAN_POINT('',(2.74045537758592,-12.6896092946067,0.516871212963336));
#481=CARTESIAN_POINT('',(2.67611127845779,-12.6843762806354,0.632413794943985));
#482=CARTESIAN_POINT('',(2.63908221505451,-12.6814846543031,0.687466614898234));
#483=CARTESIAN_POINT('',(2.5562020977221,-12.675462315215,0.79078926807542));
#484=CARTESIAN_POINT('',(2.51031959285159,-12.6723307748447,0.839033824965823));
#485=CARTESIAN_POINT('',(2.41109523036108,-12.6661885904761,0.927158796565385));
#486=CARTESIAN_POINT('',(2.35775157836591,-12.6631779757849,0.967037193462954));
#487=CARTESIAN_POINT('',(2.24499082175242,-12.6576112528024,1.0373661756717));
#488=CARTESIAN_POINT('',(2.18556036168935,-12.6550561792009,1.06779541201759));
#489=CARTESIAN_POINT('',(2.06244889714841,-12.650702271855,1.11820304164564));
#490=CARTESIAN_POINT('',(1.99877282150361,-12.6489025782952,1.13819332348896));
#491=CARTESIAN_POINT('',(1.89167449576564,-12.6467210427722,1.16212349300167));
#492=CARTESIAN_POINT('',(1.84893882442729,-12.6460635793944,1.16923007591577));
#493=CARTESIAN_POINT('',(1.76294175337525,-12.6451826119686,1.1787192621675));
#494=CARTESIAN_POINT('',(1.71968035550376,-12.6449591064004,1.18110188205355));
#495=CARTESIAN_POINT('',(1.6764,-12.644959580402,1.1811));
#496=B_SPLINE_CURVE_WITH_KNOTS('',3,(#418,#419,#420,#421,#422,#423,#424,#425,#426,#427,#428,
#429,#430,#431,#432,#433,#434,#435,#436,#437,#438,#439,#440,#441,#442,#443,#444,#445,#446,#447,
#448,#449,#450,#451,#452,#453,#454,#455,#456,#457,#458,#459,#460,#461,#462,#463,#464,#465,#466,
#467,#468,#469,#470,#471,#472,#473,#474,#475,#476,#477,#478,#479,#480,#481,#482,#483,#484,#485,
#486,#487,#488,#489,#490,#491,#492,#493,#494,#495),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.198408391584314,
0.397038285786831,0.595551323698282,0.794023628387073,0.993053675482812,1.19209264327913,
1.39149158450867,1.5908862717209,1.78970014562483,1.98850950829665,2.18670430211945,
2.38490136954014,2.58340100329621,2.78190566644961,2.98116171882059,3.18041800013575,
3.37970806687135,3.57899289700959,3.7775323065241,3.97606940163261,4.17424773188561,
4.3724300044839,4.57119722919029,4.76996870982841,4.96935767283226,5.16874422724549,
5.36781916362727,5.56688931349267,5.76520846273398,5.96352782201796,6.16182765769075,
6.36012546511067,6.55914112402377,6.75820472794397,6.95771486786726,7.15699729437504,
7.28673547433086,7.41647319980266),.UNSPECIFIED.);
#497=CARTESIAN_POINT('',(1.6764,-12.644959580402,1.1811));
#498=VERTEX_POINT('',#497);
#499=EDGE_CURVE('E84',#498,#498,#496,.T.);
#500=ORIENTED_EDGE('',*,*,#499,.T.);
#501=EDGE_LOOP('',(#500));
#502=FACE_BOUND('',#501,.T.);
#503=CARTESIAN_POINT('',(1.6764,12.644959580402,1.1811));
#504=CARTESIAN_POINT('',(1.7425888104749,12.6449603052943,1.18109712176843));
#505=CARTESIAN_POINT('',(1.80882195849135,12.6454848668838,1.17551744194701));
#506=CARTESIAN_POINT('',(1.93945357706993,12.6475262641686,1.15334235555994));
#507=CARTESIAN_POINT('',(2.00384991685363,12.6490442069825,1.13673465801948));
#508=CARTESIAN_POINT('',(2.12889715706824,12.6528989713156,1.09298985533183));
#509=CARTESIAN_POINT('',(2.1895502386967,12.6552353105536,1.06585895050645));
#510=CARTESIAN_POINT('',(2.3054279322327,12.6604630234231,1.0018494103816));
#511=CARTESIAN_POINT('',(2.36065365546332,12.6633542830678,0.964972776377593));
#512=CARTESIAN_POINT('',(2.46429738687701,12.6693763199196,0.882392964786675));
#513=CARTESIAN_POINT('',(2.51269582804942,12.6725077473809,0.836665274263883));
#514=CARTESIAN_POINT('',(2.60114281094687,12.6786513632269,0.737733579896172));
#515=CARTESIAN_POINT('',(2.64119097832488,12.6816635462609,0.684529241048222));
#516=CARTESIAN_POINT('',(2.71186724317967,12.687235603915,0.572035879025251));
#517=CARTESIAN_POINT('',(2.74247817292487,12.6897946506567,0.512736025373325));
#518=CARTESIAN_POINT('',(2.7933012126287,12.6941650514623,0.38981028493874));
#519=CARTESIAN_POINT('',(2.81351354442391,12.6959764214764,0.326184490475537));
#520=CARTESIAN_POINT('',(2.84290865732138,12.6986428199913,0.196609569577913));
#521=CARTESIAN_POINT('',(2.85212339471026,12.6995006188334,0.130667750594227));
#522=CARTESIAN_POINT('',(2.85936058493474,12.7001726325272,-0.0018317145862952));
#523=CARTESIAN_POINT('',(2.85738329172673,12.6999868710582,-0.068389346775611));
#524=CARTESIAN_POINT('',(2.84231857438978,12.6985949696696,-0.200014289064133));
#525=CARTESIAN_POINT('',(2.82926551331455,12.6973919857671,-0.265085570105092));
#526=CARTESIAN_POINT('',(2.79247327706468,12.6941045119793,-0.392109686661056));
#527=CARTESIAN_POINT('',(2.76873397930567,12.6920200119818,-0.454062486394152));
#528=CARTESIAN_POINT('',(2.71120518939936,12.6871984987081,-0.573199801152148));
#529=CARTESIAN_POINT('',(2.67740041001576,12.6844604941672,-0.630376892564856));
#530=CARTESIAN_POINT('',(2.60071134988128,12.6786394057851,-0.738258729949108));
#531=CARTESIAN_POINT('',(2.55782683910422,12.6755563132024,-0.788963311893736));
#532=CARTESIAN_POINT('',(2.46400220810512,12.6693774829036,-0.882661927585866));
#533=CARTESIAN_POINT('',(2.41303220986349,12.6662817414975,-0.925626048502373));
#534=CARTESIAN_POINT('',(2.30458728056721,12.6604382081042,-1.00239277882805));
#535=CARTESIAN_POINT('',(2.2471123420385,12.6576904165169,-1.03619537771064));
#536=CARTESIAN_POINT('',(2.1272669240317,12.6528535396737,-1.09367894797377));
#537=CARTESIAN_POINT('',(2.06489561612975,12.6507645661854,-1.11735820218344));
#538=CARTESIAN_POINT('',(1.93703871801766,12.6474841192613,-1.15389991970517));
#539=CARTESIAN_POINT('',(1.87155320968228,12.6462926222441,-1.16676266722568));
#540=CARTESIAN_POINT('',(1.73958902952871,12.6449460149639,-1.18126803715863));
#541=CARTESIAN_POINT('',(1.67311498883668,12.644787044789,-1.18295244824286));
#542=CARTESIAN_POINT('',(1.54083042985993,12.6455133046085,-1.17516295293092));
#543=CARTESIAN_POINT('',(1.47501990384945,12.6463985224304,-1.16568917660882));
#544=CARTESIAN_POINT('',(1.34605148732367,12.6491099023827,-1.1358871397878));
#545=CARTESIAN_POINT('',(1.28288901828254,12.6509343612968,-1.11557852473258));
#546=CARTESIAN_POINT('',(1.1608675638851,12.655317259616,-1.0647033158799));
#547=CARTESIAN_POINT('',(1.10200866416263,12.6578757136214,-1.03413651802934));
#548=CARTESIAN_POINT('',(0.990074328525275,12.6634476814418,-0.963507470662524));
#549=CARTESIAN_POINT('',(0.937016475774371,12.6664625161162,-0.92341746079364));
#550=CARTESIAN_POINT('',(0.838368393804923,12.6726031662766,-0.834919920463822));
#551=CARTESIAN_POINT('',(0.792778324504752,12.6757289841374,-0.786512211929531));
#552=CARTESIAN_POINT('',(0.71021648479059,12.6817509844255,-0.682572413844798));
#553=CARTESIAN_POINT('',(0.67327192702638,12.6846464233266,-0.627018659598213));
#554=CARTESIAN_POINT('',(0.609236848571931,12.6898706541552,-0.510471158452592));
#555=CARTESIAN_POINT('',(0.582146208851701,12.6921994529272,-0.449477477276007));
#556=CARTESIAN_POINT('',(0.538634356392633,12.6960246268698,-0.323877611901053));
#557=CARTESIAN_POINT('',(0.522196534750135,12.6975222973335,-0.259277222608949));
#558=CARTESIAN_POINT('',(0.50040268736077,12.6995217595164,-0.1282188092889));
#559=CARTESIAN_POINT('',(0.49504639517501,12.7000235751794,-0.0617608299628827));
#560=CARTESIAN_POINT('',(0.495571111246253,12.6999747966921,0.070858561270829));
#561=CARTESIAN_POINT('',(0.501409802539605,12.6994281656607,0.137020146156616));
#562=CARTESIAN_POINT('',(0.524070226939842,12.6973517366295,0.267418470714384));
#563=CARTESIAN_POINT('',(0.540891971679018,12.6958219375885,0.331655208347658));
#564=CARTESIAN_POINT('',(0.585029686051273,12.6919506766174,0.456381395331927));
#565=CARTESIAN_POINT('',(0.61234462241408,12.6896092946067,0.516871212963336));
#566=CARTESIAN_POINT('',(0.676688721542203,12.6843762806354,0.632413794943985));
#567=CARTESIAN_POINT('',(0.71371778494549,12.6814846543031,0.687466614898234));
#568=CARTESIAN_POINT('',(0.796597902277899,12.675462315215,0.79078926807542));
#569=CARTESIAN_POINT('',(0.842480407148406,12.6723307748447,0.839033824965823));
#570=CARTESIAN_POINT('',(0.941704769638915,12.6661885904761,0.927158796565386));
#571=CARTESIAN_POINT('',(0.995048421634082,12.6631779757849,0.967037193462954));
#572=CARTESIAN_POINT('',(1.10780917824758,12.6576112528024,1.0373661756717));
#573=CARTESIAN_POINT('',(1.16723963831065,12.6550561792009,1.06779541201759));
#574=CARTESIAN_POINT('',(1.29035110285159,12.650702271855,1.11820304164564));
#575=CARTESIAN_POINT('',(1.35402717849639,12.6489025782952,1.13819332348896));
#576=CARTESIAN_POINT('',(1.46112550423435,12.6467210427722,1.16212349300167));
#577=CARTESIAN_POINT('',(1.50386117557271,12.6460635793944,1.16923007591577));
#578=CARTESIAN_POINT('',(1.58985824662475,12.6451826119686,1.1787192621675));
#579=CARTESIAN_POINT('',(1.63311964449624,12.6449591064004,1.18110188205355));
#580=CARTESIAN_POINT('',(1.6764,12.644959580402,1.1811));
#581=B_SPLINE_CURVE_WITH_KNOTS('',3,(#503,#504,#505,#506,#507,#508,#509,#510,#511,#512,#513,
#514,#515,#516,#517,#518,#519,#520,#521,#522,#523,#524,#525,#526,#527,#528,#529,#530,#531,#532,
#533,#534,#535,#536,#537,#538,#539,#540,#541,#542,#543,#544,#545,#546,#547,#548,#549,#550,#551,
#552,#553,#554,#555,#556,#557,#558,#559,#560,#561,#562,#563,#564,#565,#566,#567,#568,#569,#570,
#571,#572,#573,#574,#575,#576,#577,#578,#579,#580),.UNSPECIFIED.,.T.,.F.,(4,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,4),(0.,0.198408391584315,
0.397038285786831,0.595551323698282,0.794023628387073,0.993053675482813,1.19209264327913,
1.39149158450867,1.5908862717209,1.78970014562483,1.98850950829665,2.18670430211945,
2.38490136954014,2.58340100329621,2.78190566644961,2.98116171882059,3.18041800013575,
3.37970806687135,3.57899289700959,3.7775323065241,3.97606940163261,4.17424773188561,
4.3724300044839,4.57119722919029,4.76996870982841,4.96935767283226,5.16874422724549,
5.36781916362727,5.56688931349267,5.76520846273398,5.96352782201796,6.16182765769075,
6.36012546511066,6.55914112402377,6.75820472794397,6.95771486786726,7.15699729437504,
7.28673547433086,7.41647319980266),.UNSPECIFIED.);
#582=CARTESIAN_POINT('',(1.6764,12.644959580402,1.1811));
#583=VERTEX_POINT('',#582);
#584=EDGE_CURVE('E56',#583,#583,#581,.T.);
#585=ORIENTED_EDGE('',*,*,#584,.T.);
#586=EDGE_LOOP('',(#585));
#587=FACE_BOUND('',#586,.T.);
#588=CARTESIAN_POINT('',(15.748,0.,0.));
#589=DIRECTION('',(-1.,0.,0.));
#590=DIRECTION('',(0.,0.,1.));
#591=AXIS2_PLACEMENT_3D('',#588,#589,#590);
#592=CIRCLE('',#591,12.7);
#593=CARTESIAN_POINT('',(15.748,0.,12.7));
#594=VERTEX_POINT('',#593);
#595=EDGE_CURVE('E174',#594,#594,#592,.T.);
#596=ORIENTED_EDGE('',*,*,#595,.F.);
#597=EDGE_LOOP('',(#596));
#598=FACE_BOUND('',#597,.T.);
#599=ORIENTED_EDGE('',*,*,#405,.T.);
#600=EDGE_LOOP('',(#599));
#601=FACE_BOUND('',#600,.T.);
#602=ADVANCED_FACE('F89',(#502,#587,#598,#601),#417,.F.);
#603=CARTESIAN_POINT('',(15.748,16.6243,0.));
#604=DIRECTION('',(-1.,0.,0.));
#605=DIRECTION('',(0.,0.,1.));
#606=AXIS2_PLACEMENT_3D('',#603,#604,#605);
#607=PLANE('',#606);
#608=CARTESIAN_POINT('',(15.748,0.,0.));
#609=DIRECTION('',(-1.,0.,0.));
#610=DIRECTION('',(0.,0.,1.));
#611=AXIS2_PLACEMENT_3D('',#608,#609,#610);
#612=CIRCLE('',#611,15.8623);
#613=CARTESIAN_POINT('',(15.748,0.,15.8623));
#614=VERTEX_POINT('',#613);
#615=EDGE_CURVE('E186',#614,#614,#612,.F.);
#616=ORIENTED_EDGE('',*,*,#615,.T.);
#617=EDGE_LOOP('',(#616));
#618=FACE_BOUND('',#617,.T.);
#619=ORIENTED_EDGE('',*,*,#595,.T.);
#620=EDGE_LOOP('',(#619));
#621=FACE_BOUND('',#620,.T.);
#622=ADVANCED_FACE('F94',(#618,#621),#607,.F.);
#623=CARTESIAN_POINT('',(0.,0.,0.));
#624=DIRECTION('',(-1.,0.,0.));
#625=DIRECTION('',(0.,0.,1.));
#626=AXIS2_PLACEMENT_3D('',#623,#624,#625);
#627=CYLINDRICAL_SURFACE('',#626,16.6243);
#628=CARTESIAN_POINT('',(14.986,0.,0.));
#629=DIRECTION('',(-1.,0.,0.));
#630=DIRECTION('',(0.,0.,1.));
#631=AXIS2_PLACEMENT_3D('',#628,#629,#630);
#632=CIRCLE('',#631,16.6243);
#633=CARTESIAN_POINT('',(14.986,0.,16.6243));
#634=VERTEX_POINT('',#633);
#635=EDGE_CURVE('E183',#634,#634,#632,.T.);
#636=ORIENTED_EDGE('',*,*,#635,.T.);
#637=EDGE_LOOP('',(#636));
#638=FACE_BOUND('',#637,.T.);
#639=CARTESIAN_POINT('',(11.557,0.,0.));
#640=DIRECTION('',(-1.,0.,0.));
#641=DIRECTION('',(0.,0.,1.));
#642=AXIS2_PLACEMENT_3D('',#639,#640,#641);
#643=CIRCLE('',#642,16.6243);
#644=CARTESIAN_POINT('',(11.557,0.,16.6243));
#645=VERTEX_POINT('',#644);
#646=EDGE_CURVE('E171',#645,#645,#643,.T.);
#647=ORIENTED_EDGE('',*,*,#646,.F.);
#648=EDGE_LOOP('',(#647));
#649=FACE_BOUND('',#648,.T.);
#650=ADVANCED_FACE('F229',(#638,#649),#627,.T.);
#651=CARTESIAN_POINT('',(11.557,16.6243,0.));
#652=DIRECTION('',(1.,0.,0.));
#653=DIRECTION('',(0.,0.,-1.));
#654=AXIS2_PLACEMENT_3D('',#651,#652,#653);
#655=PLANE('',#654);
#656=ORIENTED_EDGE('',*,*,#252,.F.);
#657=EDGE_LOOP('',(#656));
#658=FACE_BOUND('',#657,.T.);
#659=ORIENTED_EDGE('',*,*,#646,.T.);
#660=EDGE_LOOP('',(#659));
#661=FACE_BOUND('',#660,.T.);
#662=ADVANCED_FACE('F227',(#658,#661),#655,.F.);
#663=CARTESIAN_POINT('',(8.001,15.3543,0.));
#664=DIRECTION('',(-1.,0.,0.));
#665=DIRECTION('',(0.,0.,1.));
#666=AXIS2_PLACEMENT_3D('',#663,#664,#665);
#667=PLANE('',#666);
#668=CARTESIAN_POINT('',(8.001,0.,0.));
#669=DIRECTION('',(-1.,0.,0.));
#670=DIRECTION('',(0.,0.,1.));
#671=AXIS2_PLACEMENT_3D('',#668,#669,#670);
#672=CIRCLE('',#671,16.6243);
#673=CARTESIAN_POINT('',(8.001,0.,16.6243));
#674=VERTEX_POINT('',#673);
#675=EDGE_CURVE('E155',#674,#674,#672,.T.);
#676=ORIENTED_EDGE('',*,*,#675,.F.);
#677=EDGE_LOOP('',(#676));
#678=FACE_BOUND('',#677,.T.);
#679=ORIENTED_EDGE('',*,*,#275,.T.);
#680=EDGE_LOOP('',(#679));
#681=FACE_BOUND('',#680,.T.);
#682=ADVANCED_FACE('F226',(#678,#681),#667,.F.);
#683=CARTESIAN_POINT('',(0.,0.,0.));
#684=DIRECTION('',(-1.,0.,0.));
#685=DIRECTION('',(0.,0.,1.));
#686=AXIS2_PLACEMENT_3D('',#683,#684,#685);
#687=CYLINDRICAL_SURFACE('',#686,16.6243);
#688=CARTESIAN_POINT('',(5.588,0.,0.));
#689=DIRECTION('',(-1.,0.,0.));
#690=DIRECTION('',(0.,0.,1.));
#691=AXIS2_PLACEMENT_3D('',#688,#689,#690);
#692=CIRCLE('',#691,16.6243);
#693=CARTESIAN_POINT('',(5.588,0.,16.6243));
#694=VERTEX_POINT('',#693);
#695=EDGE_CURVE('E153',#694,#694,#692,.T.);
#696=ORIENTED_EDGE('',*,*,#695,.F.);
#697=EDGE_LOOP('',(#696));
#698=FACE_BOUND('',#697,.T.);
#699=ORIENTED_EDGE('',*,*,#675,.T.);
#700=EDGE_LOOP('',(#699));
#701=FACE_BOUND('',#700,.T.);
#702=ADVANCED_FACE('F281',(#698,#701),#687,.T.);
#703=CARTESIAN_POINT('',(0.,0.,0.));
#704=DIRECTION('',(-1.,0.,0.));
#705=DIRECTION('',(0.,0.,1.));
#706=AXIS2_PLACEMENT_3D('',#703,#704,#705);
#707=CYLINDRICAL_SURFACE('',#706,16.6243);
#708=CARTESIAN_POINT('',(-7.0358,0.,0.));
#709=DIRECTION('',(-1.,0.,0.));
#710=DIRECTION('',(0.,0.,1.));
#711=AXIS2_PLACEMENT_3D('',#708,#709,#710);
#712=CIRCLE('',#711,16.6243);
#713=CARTESIAN_POINT('',(-7.0358,0.,16.6243));
#714=VERTEX_POINT('',#713);
#715=EDGE_CURVE('E156',#714,#714,#712,.T.);
#716=ORIENTED_EDGE('',*,*,#715,.F.);
#717=EDGE_LOOP('',(#716));
#718=FACE_BOUND('',#717,.T.);
#719=CARTESIAN_POINT('',(-4.6228,0.,0.));
#720=DIRECTION('',(-1.,0.,0.));
#721=DIRECTION('',(0.,0.,1.));
#722=AXIS2_PLACEMENT_3D('',#719,#720,#721);
#723=CIRCLE('',#722,16.6243);
#724=CARTESIAN_POINT('',(-4.6228,0.,16.6243));
#725=VERTEX_POINT('',#724);
#726=EDGE_CURVE('E85',#725,#725,#723,.T.);
#727=ORIENTED_EDGE('',*,*,#726,.T.);
#728=EDGE_LOOP('',(#727));
#729=FACE_BOUND('',#728,.T.);
#730=ADVANCED_FACE('F141',(#718,#729),#707,.T.);
#731=CARTESIAN_POINT('',(-7.0358,15.3543,0.));
#732=DIRECTION('',(1.,0.,0.));
#733=DIRECTION('',(0.,0.,-1.));
#734=AXIS2_PLACEMENT_3D('',#731,#732,#733);
#735=PLANE('',#734);
#736=ORIENTED_EDGE('',*,*,#326,.F.);
#737=EDGE_LOOP('',(#736));
#738=FACE_BOUND('',#737,.T.);
#739=ORIENTED_EDGE('',*,*,#715,.T.);
#740=EDGE_LOOP('',(#739));
#741=FACE_BOUND('',#740,.T.);
#742=ADVANCED_FACE('F273',(#738,#741),#735,.F.);
#743=CARTESIAN_POINT('',(-10.5918,16.6243,0.));
#744=DIRECTION('',(-1.,0.,0.));
#745=DIRECTION('',(0.,0.,1.));
#746=AXIS2_PLACEMENT_3D('',#743,#744,#745);
#747=PLANE('',#746);
#748=CARTESIAN_POINT('',(-10.5918,0.,0.));
#749=DIRECTION('',(-1.,0.,0.));
#750=DIRECTION('',(0.,0.,1.));
#751=AXIS2_PLACEMENT_3D('',#748,#749,#750);
#752=CIRCLE('',#751,16.6243);
#753=CARTESIAN_POINT('',(-10.5918,0.,16.6243));
#754=VERTEX_POINT('',#753);
#755=EDGE_CURVE('E255',#754,#754,#752,.T.);
#756=ORIENTED_EDGE('',*,*,#755,.F.);
#757=EDGE_LOOP('',(#756));
#758=FACE_BOUND('',#757,.T.);
#759=ORIENTED_EDGE('',*,*,#349,.T.);
#760=EDGE_LOOP('',(#759));
#761=FACE_BOUND('',#760,.T.);
#762=ADVANCED_FACE('F276',(#758,#761),#747,.F.);
#763=CARTESIAN_POINT('',(0.,0.,0.));
#764=DIRECTION('',(-1.,0.,0.));
#765=DIRECTION('',(0.,0.,1.));
#766=AXIS2_PLACEMENT_3D('',#763,#764,#765);
#767=CYLINDRICAL_SURFACE('',#766,16.6243);
#768=CARTESIAN_POINT('',(-14.986,0.,0.));
#769=DIRECTION('',(1.,0.,0.));
#770=DIRECTION('',(0.,0.,-1.));
#771=AXIS2_PLACEMENT_3D('',#768,#769,#770);
#772=CIRCLE('',#771,16.6243);
#773=CARTESIAN_POINT('',(-14.986,0.,-16.6243));
#774=VERTEX_POINT('',#773);
#775=EDGE_CURVE('E192',#774,#774,#772,.T.);
#776=ORIENTED_EDGE('',*,*,#775,.T.);
#777=EDGE_LOOP('',(#776));
#778=FACE_BOUND('',#777,.T.);
#779=ORIENTED_EDGE('',*,*,#755,.T.);
#780=EDGE_LOOP('',(#779));
#781=FACE_BOUND('',#780,.T.);
#782=ADVANCED_FACE('F116',(#778,#781),#767,.T.);
#783=CARTESIAN_POINT('',(-15.748,6.35,0.));
#784=DIRECTION('',(1.,0.,0.));
#785=DIRECTION('',(0.,0.,-1.));
#786=AXIS2_PLACEMENT_3D('',#783,#784,#785);
#787=PLANE('',#786);
#788=CARTESIAN_POINT('',(-15.748,0.,0.));
#789=DIRECTION('',(1.,0.,0.));
#790=DIRECTION('',(0.,0.,-1.));
#791=AXIS2_PLACEMENT_3D('',#788,#789,#790);
#792=CIRCLE('',#791,15.8623);
#793=CARTESIAN_POINT('',(-15.748,0.,-15.8623));
#794=VERTEX_POINT('',#793);
#795=EDGE_CURVE('E189',#794,#794,#792,.F.);
#796=ORIENTED_EDGE('',*,*,#795,.T.);
#797=EDGE_LOOP('',(#796));
#798=FACE_BOUND('',#797,.T.);
#799=ORIENTED_EDGE('',*,*,#388,.F.);
#800=EDGE_LOOP('',(#799));
#801=FACE_BOUND('',#800,.T.);
#802=ADVANCED_FACE('F108',(#798,#801),#787,.F.);
#803=CARTESIAN_POINT('',(14.986,0.,0.));
#804=DIRECTION('',(-1.,0.,0.));
#805=DIRECTION('',(0.,0.,1.));
#806=AXIS2_PLACEMENT_3D('',#803,#804,#805);
#807=CONICAL_SURFACE('',#806,16.6243,0.785398163397451);
#808=ORIENTED_EDGE('',*,*,#615,.F.);
#809=EDGE_LOOP('',(#808));
#810=FACE_BOUND('',#809,.T.);
#811=ORIENTED_EDGE('',*,*,#635,.F.);
#812=EDGE_LOOP('',(#811));
#813=FACE_BOUND('',#812,.T.);
#814=ADVANCED_FACE('F106',(#810,#813),#807,.T.);
#815=CARTESIAN_POINT('',(-15.748,0.,0.));
#816=DIRECTION('',(1.,0.,0.));
#817=DIRECTION('',(0.,0.,-1.));
#818=AXIS2_PLACEMENT_3D('',#815,#816,#817);
#819=CONICAL_SURFACE('',#818,15.8623,0.785398163397444);
#820=ORIENTED_EDGE('',*,*,#775,.F.);
#821=EDGE_LOOP('',(#820));
#822=FACE_BOUND('',#821,.T.);
#823=ORIENTED_EDGE('',*,*,#795,.F.);
#824=EDGE_LOOP('',(#823));
#825=FACE_BOUND('',#824,.T.);
#826=ADVANCED_FACE('F33',(#822,#825),#819,.T.);
#827=CARTESIAN_POINT('',(-10.5156,15.3543,0.));
#828=DIRECTION('',(1.,0.,0.));
#829=DIRECTION('',(0.,0.,-1.));
#830=AXIS2_PLACEMENT_3D('',#827,#828,#829);
#831=PLANE('',#830);
#832=ORIENTED_EDGE('',*,*,#360,.T.);
#833=EDGE_LOOP('',(#832));
#834=FACE_BOUND('',#833,.T.);
#835=CARTESIAN_POINT('',(-10.5156,0.,0.));
#836=DIRECTION('',(-1.,0.,0.));
#837=DIRECTION('',(0.,0.,1.));
#838=AXIS2_PLACEMENT_3D('',#835,#836,#837);
#839=CIRCLE('',#838,16.7005);
#840=CARTESIAN_POINT('',(-10.5156,0.,16.7005));
#841=VERTEX_POINT('',#840);
#842=EDGE_CURVE('E256',#841,#841,#839,.T.);
#843=ORIENTED_EDGE('',*,*,#842,.T.);
#844=EDGE_LOOP('',(#843));
#845=FACE_BOUND('',#844,.T.);
#846=ADVANCED_FACE('F114',(#834,#845),#831,.F.);
#847=CARTESIAN_POINT('',(0.,0.,0.));
#848=DIRECTION('',(-1.,0.,0.));
#849=DIRECTION('',(0.,0.,1.));
#850=AXIS2_PLACEMENT_3D('',#847,#848,#849);
#851=CYLINDRICAL_SURFACE('',#850,16.7005);
#852=ORIENTED_EDGE('',*,*,#842,.F.);
#853=EDGE_LOOP('',(#852));
#854=FACE_BOUND('',#853,.T.);
#855=CARTESIAN_POINT('',(-9.271,0.,0.));
#856=DIRECTION('',(-1.,0.,0.));
#857=DIRECTION('',(0.,0.,1.));
#858=AXIS2_PLACEMENT_3D('',#855,#856,#857);
#859=CIRCLE('',#858,16.7005);
#860=CARTESIAN_POINT('',(-9.271,0.,16.7005));
#861=VERTEX_POINT('',#860);
#862=EDGE_CURVE('E262',#861,#861,#859,.T.);
#863=ORIENTED_EDGE('',*,*,#862,.T.);
#864=EDGE_LOOP('',(#863));
#865=FACE_BOUND('',#864,.T.);
#866=ADVANCED_FACE('F297',(#854,#865),#851,.T.);
#867=CARTESIAN_POINT('',(-9.271,15.3543,0.));
#868=DIRECTION('',(-1.,0.,0.));
#869=DIRECTION('',(0.,0.,1.));
#870=AXIS2_PLACEMENT_3D('',#867,#868,#869);
#871=PLANE('',#870);
#872=ORIENTED_EDGE('',*,*,#862,.F.);
#873=EDGE_LOOP('',(#872));
#874=FACE_BOUND('',#873,.T.);
#875=ORIENTED_EDGE('',*,*,#303,.T.);
#876=EDGE_LOOP('',(#875));
#877=FACE_BOUND('',#876,.T.);
#878=ADVANCED_FACE('F301',(#874,#877),#871,.F.);
#879=CARTESIAN_POINT('',(-8.001,0.,0.));
#880=DIRECTION('',(-1.,0.,0.));
#881=DIRECTION('',(0.,0.,1.));
#882=AXIS2_PLACEMENT_3D('',#879,#880,#881);
#883=TOROIDAL_SURFACE('',#882,16.1671,0.889000000000002);
#884=ORIENTED_EDGE('',*,*,#337,.T.);
#885=EDGE_LOOP('',(#884));
#886=FACE_BOUND('',#885,.T.);
#887=ORIENTED_EDGE('',*,*,#314,.T.);
#888=EDGE_LOOP('',(#887));
#889=FACE_BOUND('',#888,.T.);
#890=ADVANCED_FACE('F305',(#886,#889),#883,.T.);
#891=CARTESIAN_POINT('',(8.9662,0.,0.));
#892=DIRECTION('',(-1.,0.,0.));
#893=DIRECTION('',(0.,0.,1.));
#894=AXIS2_PLACEMENT_3D('',#891,#892,#893);
#895=TOROIDAL_SURFACE('',#894,16.1671,0.889000000000002);
#896=ORIENTED_EDGE('',*,*,#229,.T.);
#897=EDGE_LOOP('',(#896));
#898=FACE_BOUND('',#897,.T.);
#899=ORIENTED_EDGE('',*,*,#286,.T.);
#900=EDGE_LOOP('',(#899));
#901=FACE_BOUND('',#900,.T.);
#902=ADVANCED_FACE('F309',(#898,#901),#895,.T.);
#903=CARTESIAN_POINT('',(10.2362,15.3543,0.));
#904=DIRECTION('',(1.,0.,0.));
#905=DIRECTION('',(0.,0.,-1.));
#906=AXIS2_PLACEMENT_3D('',#903,#904,#905);
#907=PLANE('',#906);
#908=ORIENTED_EDGE('',*,*,#240,.T.);
#909=EDGE_LOOP('',(#908));
#910=FACE_BOUND('',#909,.T.);
#911=CARTESIAN_POINT('',(10.2362,0.,0.));
#912=DIRECTION('',(-1.,0.,0.));
#913=DIRECTION('',(0.,0.,1.));
#914=AXIS2_PLACEMENT_3D('',#911,#912,#913);
#915=CIRCLE('',#914,16.7005);
#916=CARTESIAN_POINT('',(10.2362,0.,16.7005));
#917=VERTEX_POINT('',#916);
#918=EDGE_CURVE('E327',#917,#917,#915,.T.);
#919=ORIENTED_EDGE('',*,*,#918,.T.);
#920=EDGE_LOOP('',(#919));
#921=FACE_BOUND('',#920,.T.);
#922=ADVANCED_FACE('F313',(#910,#921),#907,.F.);
#923=CARTESIAN_POINT('',(0.,0.,0.));
#924=DIRECTION('',(-1.,0.,0.));
#925=DIRECTION('',(0.,0.,1.));
#926=AXIS2_PLACEMENT_3D('',#923,#924,#925);
#927=CYLINDRICAL_SURFACE('',#926,16.7005);
#928=ORIENTED_EDGE('',*,*,#918,.F.);
#929=EDGE_LOOP('',(#928));
#930=FACE_BOUND('',#929,.T.);
#931=CARTESIAN_POINT('',(11.4808,0.,0.));
#932=DIRECTION('',(-1.,0.,0.));
#933=DIRECTION('',(0.,0.,1.));
#934=AXIS2_PLACEMENT_3D('',#931,#932,#933);
#935=CIRCLE('',#934,16.7005);
#936=CARTESIAN_POINT('',(11.4808,0.,16.7005));
#937=VERTEX_POINT('',#936);
#938=EDGE_CURVE('E330',#937,#937,#935,.T.);
#939=ORIENTED_EDGE('',*,*,#938,.T.);
#940=EDGE_LOOP('',(#939));
#941=FACE_BOUND('',#940,.T.);
#942=ADVANCED_FACE('F316',(#930,#941),#927,.T.);
#943=CARTESIAN_POINT('',(11.4808,15.3543,0.));
#944=DIRECTION('',(-1.,0.,0.));
#945=DIRECTION('',(0.,0.,1.));
#946=AXIS2_PLACEMENT_3D('',#943,#944,#945);
#947=PLANE('',#946);
#948=ORIENTED_EDGE('',*,*,#938,.F.);
#949=EDGE_LOOP('',(#948));
#950=FACE_BOUND('',#949,.T.);
#951=ORIENTED_EDGE('',*,*,#263,.T.);
#952=EDGE_LOOP('',(#951));
#953=FACE_BOUND('',#952,.T.);
#954=ADVANCED_FACE('F72',(#950,#953),#947,.F.);
#955=CARTESIAN_POINT('',(1.6764,-17.0561,0.));
#956=DIRECTION('',(0.,1.,0.));
#957=DIRECTION('',(0.,0.,1.));
#958=AXIS2_PLACEMENT_3D('',#955,#956,#957);
#959=CYLINDRICAL_SURFACE('',#958,1.1811);
#960=ORIENTED_EDGE('',*,*,#201,.F.);
#961=EDGE_LOOP('',(#960));
#962=FACE_BOUND('',#961,.T.);
#963=ORIENTED_EDGE('',*,*,#584,.F.);
#964=EDGE_LOOP('',(#963));
#965=FACE_BOUND('',#964,.T.);
#966=ADVANCED_FACE('F69',(#962,#965),#959,.F.);
#967=ORIENTED_EDGE('',*,*,#116,.F.);
#968=EDGE_LOOP('',(#967));
#969=FACE_BOUND('',#968,.T.);
#970=ORIENTED_EDGE('',*,*,#499,.F.);
#971=EDGE_LOOP('',(#970));
#972=FACE_BOUND('',#971,.T.);
#973=ADVANCED_FACE('F63',(#969,#972),#959,.F.);
#974=CARTESIAN_POINT('',(-3.3029772846325,0.,0.));
#975=DIRECTION('',(-1.,0.,0.));
#976=DIRECTION('',(0.,0.,1.));
#977=AXIS2_PLACEMENT_3D('',#974,#975,#976);
#978=CONICAL_SURFACE('',#977,15.8623,0.523598775598293);
#979=ORIENTED_EDGE('',*,*,#726,.F.);
#980=EDGE_LOOP('',(#979));
#981=FACE_BOUND('',#980,.T.);
#982=ORIENTED_EDGE('',*,*,#31,.T.);
#983=EDGE_LOOP('',(#982));
#984=FACE_BOUND('',#983,.T.);
#985=ADVANCED_FACE('F68',(#981,#984),#978,.T.);
#986=CARTESIAN_POINT('',(5.588,0.,0.));
#987=DIRECTION('',(1.,0.,0.));
#988=DIRECTION('',(0.,0.,-1.));
#989=AXIS2_PLACEMENT_3D('',#986,#987,#988);
#990=CONICAL_SURFACE('',#989,16.6243,0.523598775598293);
#991=ORIENTED_EDGE('',*,*,#212,.T.);
#992=EDGE_LOOP('',(#991));
#993=FACE_BOUND('',#992,.T.);
#994=ORIENTED_EDGE('',*,*,#695,.T.);
#995=EDGE_LOOP('',(#994));
#996=FACE_BOUND('',#995,.T.);
#997=ADVANCED_FACE('F144',(#993,#996),#990,.T.);
#998=CLOSED_SHELL('',(#216,#244,#267,#290,#318,#341,#364,#392,#412,#602,#622,#650,#662,#682,
#702,#730,#742,#762,#782,#802,#814,#826,#846,#866,#878,#890,#902,#922,#942,#954,#966,#973,#985,#997));
#999=MANIFOLD_SOLID_BREP('B2',#998);
#1000=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#999),#14);
#1001=SHAPE_DEFINITION_REPRESENTATION(#9,#1000);
ENDSEC;
END-ISO-10303-21;
